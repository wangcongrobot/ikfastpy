Commit message: update hdt new urdf

File: hdt_robot_old.urdf (robot description, URDF)
Before this commit: robot hdt_arm, 12 links, 11 joints
Joints:
- joint drive4_joint: axis 0 0 -1 -> 0 0 1
- joint drive5_joint: axis 0 0 -1 -> 0 0 1
- joint drive6_joint: axis 0 0 -1 -> 0 0 1
